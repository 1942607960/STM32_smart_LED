# Keil uVision project Ultrasonic.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Ultrasonic +hex
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c include: ..\Libraries\CMSIS;..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\User;..\User\led;..\User\Timbase;..\User\Ultrasonic;..\User\delay;..\User\iwdg;..\User\OLED;..\User\usart;..\User\DHT11;..\User\BH1750;..\User\sys;..\User\ds1302;..\User\KEY;..\User\beep;..\User\PWM;..\Gizwits\gizwits_product;..\Gizwits\gizwits_protocol;..\Utils\common;..\Utils\dataPointTools;..\Utils\ringbuffer;..\User\usart2;..\User\USART3;..\User\usart
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group STARTUP
    ../Libraries/CMSIS/startup/: startup_stm32f10x_md.s
  group CMSIS
    ../Libraries/CMSIS/: core_cm3.c system_stm32f10x.c
  group FWLIB
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group USER
    ../User/: main.c stm32f10x_it.c
    ../User/Timbase/: bsp_Timbase.c
    ../User/delay/: delay.c
    ../User/OLED/: bsp_oled.c
    ../User/sys/: sys.c
    ../User/ds1302/: ds1302.c
    ../User/DHT11/: dht11.c
    ../User/KEY/: key.c
    ../User/PWM/: PWM.c
    ../User/usart2/: usart2.c
    ../User/USART3/: usart3.c
    ../User/usart/: usart.c
  group Gizwits
    ../Gizwits/gizwits_product/: gizwits_product.c
    ../Gizwits/gizwits_protocol/: gizwits_protocol.c
  group Utils
    ../Utils/common/: common.c
    ../Utils/dataPointTools/: dataPointTools.c
    ../Utils/ringbuffer/: ringbuffer.c
  group DOC
    ../Doc/: readme.txt
software components: CMSIS:CORE 5.2.0
